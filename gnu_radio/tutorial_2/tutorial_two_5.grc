<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.10'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>tutorial_two_5</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>32000</value></param>
</block>
<block>
<key>variable_function_probe</key>
<param><key>id</key><value>variable_function_probe_0</value></param>
<param><key>block_id</key><value>blocks_probe_signal_x_0</value></param>
<param><key>function_name</key><value>level</value></param>
<param><key>value</key><value>0</value></param>
<param><key>poll_rate</key><value>10</value></param>
</block>
<block>
<key>variable_qtgui_entry</key>
<param><key>id</key><value>variable_qtgui_entry_0</value></param>
<param><key>value</key><value>0</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>variable_qtgui_label</key>
<param><key>id</key><value>variable_qtgui_label_0</value></param>
<param><key>value</key><value>0</value></param>
<param><key>label</key><value>variable_function_probe_0</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>analog_sig_source_x</key>
<param><key>id</key><value>analog_sig_source_x_0</value></param>
<param><key>amp</key><value>1</value></param>
<param><key>freq</key><value>1000</value></param>
<param><key>offset</key><value>0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>waveform</key><value>analog.GR_COS_WAVE</value></param>
</block>
<block>
<key>blocks_probe_signal_x</key>
<param><key>id</key><value>blocks_probe_signal_x_0</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0</value></param>
<param><key>samples_per_second</key><value>samp_rate</value></param>
<param><key>type</key><value>float</value></param>
</block>
<connection><source_block_id>analog_sig_source_x_0</source_block_id><sink_block_id>blocks_throttle_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>blocks_probe_signal_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
